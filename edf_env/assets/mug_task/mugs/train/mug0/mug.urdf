Commit message: change dir

File: edf_env/assets/mug_task/mugs/train/mug0/mug.urdf (robot description, URDF)
Before this commit: robot mug, 1 links, 0 joints
Links:
- link base_link: geometry collision mesh filename=mug.obj; visual mesh filename=mug.obj
