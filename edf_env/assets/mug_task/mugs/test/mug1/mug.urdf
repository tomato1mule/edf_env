Commit message: stable sim

File: edf_env/assets/mug_task/mugs/test/mug1/mug.urdf (robot description, URDF)
Before this commit: robot mug, 1 links, 0 joints
Links:
- link base_link: mass 1 -> 0.1
