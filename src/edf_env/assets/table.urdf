Commit message: new table

File: src/edf_env/assets/table.urdf (robot description, URDF)
Before this commit: robot table.urdf, 1 links, 0 joints
Links:
- link baseLink: geometry collision box size=1.8 1 0.05; visual mesh filename=table.obj scale=0.06 0.06 0.58
